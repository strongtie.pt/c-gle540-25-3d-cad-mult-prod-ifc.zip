Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:22:58
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:22:58 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{05D91CF0-A2A8-451A-A9A2-8A81D5C4FFA4}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:22:57 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:22:58 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:22:58 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Normal Holes\RFA 3D\GLE540_68_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Weight: 1; Line Pattern: -3000010; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GLE540_68_25, GLE540_68_25:GLE540_68_25:105671
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00424634 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE540/68/2.5
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE540/68/2.5; Density: 0.922; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Identity Data - Copyright: ©Simpson Strong-Tie; Model: GLE540/68/2.5; Name: GLE540/68/2.5; OmniClass Number: 23.20.40.11.24.14; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; ObjectType: GLE540/68/2.5; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Manufacturer: Simpson Strong-Tie; Model ID: 0238633509286448766558399637212397222310; URL: www.strongtie.eu; Description: Joist hanger; OmniClass Title: Wood Connectors
Materials and Finishes - Product Material: Galvanised
