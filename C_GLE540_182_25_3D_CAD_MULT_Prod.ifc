Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:12:40
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:12:40 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{9FA352C4-EA23-4C5E-9614-56F5F9ECCD3E}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:12:40 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:12:40 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:12:40 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE540_182_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Weight: 1; Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Dimensions - Computation Height: 0 mm
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point

# IfcBuildingElementProxy: GLE540_182_25, GLE540_182_25:GLE540_182_25:118859
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00425424 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE540/182/2.5
Identity Data - Name: GLE540/182/2.5; Model ID: 0091885215669378180997711724626713274103; Manufacturer: Simpson Strong-Tie; URL: www.strongtie.eu; Product Type: Joist hanger; Model: GLE540/182/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; ObjectType: GLE540/182/2.5; Description: Joist hanger; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors; Copyright: ©Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; OmniClass Number: 23.20.40.11.24.14
Materials and Finishes - Product Material: Galvanised
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 0.95; Reference: GLE540/182/2.5
