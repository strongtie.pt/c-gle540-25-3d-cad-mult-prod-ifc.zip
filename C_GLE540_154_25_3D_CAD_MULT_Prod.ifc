Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:23:24
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:23:24 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{F2BA7383-F9EF-457D-886D-5B5BE5049B60}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:23:24 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:23:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:23:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Normal Holes\RFA 3D\GLE540_154_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Symbol at End 2 Default: yes; Line Weight: 1; Line Pattern: -3000010; Symbol at End 1 Default: no; Color: 0
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: GLE540_154_25, GLE540_154_25:GLE540_154_25:132675
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00424634 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE540/154/2.5
Identity Data - UniClass Title: Joist hangers; URL: www.strongtie.eu; Description: Joist hanger; OmniClass Title: Wood Connectors; UniClass Number: Pr_20_29_31_44; ObjectType: GLE540/154/2.5; Copyright: ©Simpson Strong-Tie; Model ID: 0238633509286448766558399637212397222310; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Product Type: Joist hanger; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com; Name: GLE540/154/2.5; Model: GLE540/154/2.5; Manufacturer: Simpson Strong-Tie
Materials and Finishes - Product Material: Galvanised
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 0.922; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GLE540/154/2.5
