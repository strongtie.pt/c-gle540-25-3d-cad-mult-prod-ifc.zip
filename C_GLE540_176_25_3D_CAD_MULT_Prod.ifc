Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:12:38
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:12:38 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{DC36E10C-BCC2-4E81-8436-A500B4B6A5A8}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:12:38 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:12:38 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:12:38 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE540_176_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Pattern: -3000010; Color: 0
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: GLE540_176_25, GLE540_176_25:GLE540_176_25:116975
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00425424 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE540/176/2.5
General - Reference: GLE540/176/2.5; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 0.95; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Identity Data - Model ID: 0091885215669378180997711724626713274103; URL: www.strongtie.eu; ObjectType: GLE540/176/2.5; OmniClass Number: 23.20.40.11.24.14; Model: GLE540/176/2.5; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44; Product Type: Joist hanger; Name: GLE540/176/2.5; OmniClass Title: Wood Connectors; Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Manufacturer: Simpson Strong-Tie
Materials and Finishes - Product Material: Galvanised
