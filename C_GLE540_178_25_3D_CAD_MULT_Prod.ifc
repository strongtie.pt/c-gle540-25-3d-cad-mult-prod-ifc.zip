Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:12:39
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:12:39 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{60F6B0F9-5492-49F4-8411-CB994F158B00}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:12:39 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:12:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:12:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE540_178_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: -3000010; Line Weight: 1; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: GLE540_178_25, GLE540_178_25:GLE540_178_25:117603
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00425424 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE540/178/2.5
Identity Data - OmniClass Number: 23.20.40.11.24.14; URL: www.strongtie.eu; Model ID: 0091885215669378180997711724626713274103; ObjectType: GLE540/178/2.5; Manufacturer: Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors; UniClass Title: Joist hangers; Model: GLE540/178/2.5; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Description: Joist hanger; Name: GLE540/178/2.5; Copyright: ©Simpson Strong-Tie
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE540/178/2.5; Density: 0.95; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
